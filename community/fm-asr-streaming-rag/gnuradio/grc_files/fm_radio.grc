options:
  parameters:
    generate_options: qt_gui
    id: fm_radio
    output_language: python
    title: FM Radio with audio sink
  states: {}

blocks:
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    start: '100'
    step: 10e3
    stop: 1e6
    value: 100e3
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 88.5e6
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 10e3
    step: 10e3
    stop: 8e6
    value: starting_sample_rate
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '20.0'
    value: '0.05'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:CARD=C3422WE,DEV=0
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '1'
    payloadsize: '1472'
    port: '5005'
    send_eof: 'True'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: Top flow works, sends output to speaker
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: This needs to scale to 48KHz
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(3*samp_rate/48e3)
    interp: '3'
    type: fff
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: '12500'
    freq0: freq
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: starting_sample_rate
  id: parameter
  parameters:
    label: starting_sample_rate
    value: 1e6
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [blocks_correctiq_0, '0', analog_wfm_rcv_0, '0']
- [blocks_correctiq_0, '0', network_udp_sink_0, '0']
- [blocks_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', blocks_correctiq_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
